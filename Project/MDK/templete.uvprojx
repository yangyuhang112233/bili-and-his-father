# Keil uVision project templete.uvprojx, settings and files
target mk60d10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\Libraries\devices\inc;..\..\Libraries\drivers\inc;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\src;..\..\Libraries\fatfs;..\..\Libraries\fatfs\option
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c control.c img_processing.c ov7725_Init.c getready.c getready.h
  group drivers
    ../../Libraries/drivers/src/: adc.c cmt.c common.c dac.c dma.c ftm.c gpio.c io2iic.c systick.c uart.c spi.c wdog.c pit.c sd.c
  group device
    ../../Libraries/devices/src/: Drv_LCD.c ov7725.c
    ../src/: ov7620.c ov7620_back.c img_save.c
  group fatfs
    ../../Libraries/fatfs/: ff.c diskio.c
  group control2
    ../src/: flag.c move.c response.c head.h pid.c pid.h canshu.c canshu.h qita.c qita.h
